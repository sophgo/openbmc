DEFAULT_INSTANCE = "ttyS0"

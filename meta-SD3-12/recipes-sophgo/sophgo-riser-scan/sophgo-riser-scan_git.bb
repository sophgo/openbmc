# https://www.coder.work/article/6433710

SUMMARY = "Riser slot scan"
DESCRIPTION = ""

LICENSE = "CLOSED"
LIC_FILES_CHKSUM = ""
FILESPATH := "${THISDIR}/project/:"


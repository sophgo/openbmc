PACKAGECONFIG:append = " send-to-logger log-threshold log-alarm"

FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://01-avahi-mask-ip-addr-192-168-0-45.patch"
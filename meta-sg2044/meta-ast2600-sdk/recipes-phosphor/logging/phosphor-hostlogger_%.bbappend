DEFAULT_INSTANCE = "ttyS1"
